# Allow authentication dialog to be built
PACKAGECONFIG="gnome"