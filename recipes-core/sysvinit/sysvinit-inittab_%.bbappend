# Since this is only a console lets get 3 ttys working by default
SYSVINIT_ENABLED_GETTYS = "1 2 3"
