FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://add-pixelbook-default-map.patch"
