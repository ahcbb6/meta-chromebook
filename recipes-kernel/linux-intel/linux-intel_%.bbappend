FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://extra_pixelbook.cfg"

KMACHINE_coreix-64-skylake-intel-common = "intel-corei7-64"
