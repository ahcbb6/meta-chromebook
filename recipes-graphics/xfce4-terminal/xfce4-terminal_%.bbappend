FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://change_default_preferences.patch"
