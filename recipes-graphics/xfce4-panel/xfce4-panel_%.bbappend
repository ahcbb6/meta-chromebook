FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://use_only_top_panel.patch"
