FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://pixelbook-custom-shotcuts.patch"
